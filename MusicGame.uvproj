# Keil uVision project MusicGame.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MusicGame +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\Core\Device\NXP\LPC17xx\Include;.\Libraries\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./Libraries/: startup_LPC17xx.s system_LPC17xx.c
  group Drivers
    ./Libraries/Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_uart.c
  group Header
    ./Sources/: Font.c GLCD.c GLCD.h Keypad.c Keypad.h Note.h Timer.c Timer.h Tone.c Tone.h Utility.c Utility.h
  group Source
    ./Sources/: Game.c Game.h Main.c
